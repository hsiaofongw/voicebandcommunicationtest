options:
  parameters:
    generate_options: hb
    id: custom_packet_parser
    output_language: python
    title: Custom packet parser
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"frame_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_2
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '96'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"frame_len"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '""'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: format_used
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: header_data
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.dict_add(x, pmt.string_to_symbol("frame_len"), pmt.from_long(8*pmt.to_long(pmt.dict_ref(x,pmt.string_to_symbol("payload symbols"),pmt.from_long(0)))))'
    metadict: Raw Message
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampe Rate
    type: eng_float
    value: '48000'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: first_round_decapsulate_bits
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: first_round_decapsulate_bits
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_2, '0', digital_crc32_bb_2, '0']
- [blocks_repack_bits_bb_3, '0', virtual_sink_2, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_crc32_bb_0, '0', pad_sink_0, '0']
- [digital_crc32_bb_2, '0', blocks_repack_bits_bb_3, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_protocol_parser_b_0, info, pdu_pdu_lambda_0, pdu]
- [pad_source_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [pdu_pdu_lambda_0, pdu, digital_header_payload_demux_0, header_data]
- [pdu_pdu_lambda_0, pdu, pad_sink_1, in]
- [virtual_source_4, '0', digital_header_payload_demux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
