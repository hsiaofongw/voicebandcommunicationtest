options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: test_vco
    output_language: python
    title: FSK demo
  states: {}

blocks:
- name: delay
  id: variable
  parameters:
    value: '1'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '600'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Center frequency
    start: '100'
    step: '10'
    stop: '20000'
    value: '2500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*deviation
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/32)
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: fc+deviation
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: vco.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: custom_bfsk_demod_0
  id: custom_bfsk_demod
  parameters:
    deviation: deviation
    fc: fc
    sps: sps
  states: {}
- name: custom_bfsk_mod_0
  id: custom_bfsk_mod
  parameters:
    deviation: deviation
    fc: fc
    sps: sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Tx
    label2: Rx
    nconnections: '2'
    size: int(1.5*samp_rate/sps)
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: origin
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: origin
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_1_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', custom_bfsk_mod_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [custom_bfsk_demod_0, '0', blocks_char_to_float_1, '0']
- [custom_bfsk_mod_0, '0', blocks_throttle2_0, '0']
- [custom_bfsk_mod_0, '0', custom_bfsk_demod_0, '0']
- [custom_bfsk_mod_0, '0', qtgui_waterfall_sink_x_1, '0']
- [virtual_source_0, '0', blocks_char_to_float_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
