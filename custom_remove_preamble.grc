options:
  parameters:
    generate_options: hb
    id: custom_remove_preamble
    output_language: python
    title: Custom remove preamble
  states: {}

blocks:
- name: num_pream_packets
  id: parameter
  parameters:
    label: Number of preamble garbage packets
    type: intx
    value: '10'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("select")
    v: pmt.PMT_T
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.cons(pmt.to_pmt({ ''select'': True }) if pmt.to_long(pmt.dict_ref(pmt.car(x), pmt.string_to_symbol("counter"), pmt.from_long(0))) >= num_pream_packets else pmt.to_pmt({ ''select'': False }), pmt.cdr(x))'
    metadict: Raw Message
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame_len
    type: byte
  states: {}

connections:
- [pad_source_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_pdu_filter_0, pdus, pad_sink_0, in]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_filter_0, pdus]
- [pdu_tagged_stream_to_pdu_0, pdus, pdu_pdu_lambda_1, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
