options:
  parameters:
    generate_options: hb
    id: custom_iq_complex_to_passband_real
    output_language: python
    title: IQ to Real
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: passband_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: txgain
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: passband_fc
  id: parameter
  parameters:
    label: Passband Center Frequency
    type: eng_float
    value: '1800'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '48000'
  states: {}
- name: txgain
  id: parameter
  parameters:
    label: Tx Gain
    type: eng_float
    value: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', pad_sink_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_sub_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [pad_source_0, '0', blocks_complex_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
