options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: test_bfsk_tx_demo
    output_language: python
    title: Test BFSK TX Demo
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: access_code_cplx
  id: variable
  parameters:
    value: '[(complex(x)-0.5)*2 for x in list(access_code)]'
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,1)
  states: {}
- name: lowpassfiltertaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: fc
    gain: '1.0'
    samp_rate: samp_rate
    width: deviation*1.5
    win: window.WIN_HAMMING
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*deviation
  states: {}
- name: audio_out
  id: parameter
  parameters:
    label: Audio Output
    type: str
    value: plughw:0,0,0
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_out
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: fc+deviation
    interp: '1'
    low_cutoff_freq: fc-deviation
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: deviation/2
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: 2*math.pi*fc/sensitivity
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_filename
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pkt_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: sensitivity
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: BFSK Deviation
    type: eng_float
    value: '800'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: format_used
    len_tag_key: '"packet_len"'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Center frequency
    type: eng_float
    value: '3000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: in_filename
  id: parameter
  parameters:
    label: Input filename
    type: str
    value: in.bin
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pkt_size
  id: parameter
  parameters:
    label: Packet size
    type: intx
    value: '16'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: float
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '1500'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pkt_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pkt_bytes
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_add_const_vxx_2, '0']
- [blocks_add_const_vxx_2, '0', blocks_vco_f_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_f_0, '0', band_pass_filter_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
