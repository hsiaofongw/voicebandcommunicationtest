options:
  parameters:
    generate_options: hb
    id: custom_packet_formatter
    output_language: python
    title: Custom packet formatter
  states: {}

blocks:
- name: format_default
  id: variable
  parameters:
    value: digital.header_format_default(access_code,0)
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: access_code
  id: parameter
  parameters:
    label: Access code for synchronization
    type: str
    value: '"01001"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_2
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_3
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: format_used
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_1
  id: digital_protocol_formatter_bb
  parameters:
    format: format_default
    len_tag_key: '"packet_len"'
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet size
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_3, '0']
- [blocks_tagged_stream_mux_0, '0', digital_crc32_bb_1, '0']
- [blocks_tagged_stream_mux_2, '0', pad_sink_0, '0']
- [digital_crc32_bb_1, '0', blocks_tagged_stream_mux_2, '1']
- [digital_crc32_bb_1, '0', digital_protocol_formatter_bb_1, '0']
- [digital_crc32_bb_3, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_3, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_1, '0', blocks_tagged_stream_mux_2, '0']
- [pad_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
