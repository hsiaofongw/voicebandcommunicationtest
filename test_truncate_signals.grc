options:
  parameters:
    generate_options: qt_gui
    id: test_truncate_signals
    output_language: python
    title: Test truncated signals
  states: {}

blocks:
- name: input_filename
  id: variable
  parameters:
    value: '"threekingdoms.txt"'
  states: {}
- name: output_filename
  id: variable
  parameters:
    value: '"test.bin"'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    comment: Length of preamble
    value: '32'
  states: {}
- name: read_size
  id: variable
  parameters:
    comment: How many bytes read from the content file
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: preamble_len
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: preamble_len
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_filename
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_filename
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: preamble_len + read_size
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Realize the control of the on/off of the random signal
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Here is the control signal  to control the on/off of the random signal
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,)
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Pretend as the random source
    repeat: 'True'
    type: float
    vector: (1,2,3,4)
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_1, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_file_source_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
