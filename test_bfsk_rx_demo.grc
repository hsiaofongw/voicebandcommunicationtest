options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: test_bfsk_rx_demo
    output_language: python
    title: Test BFSK RX Demo
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: access_code_cplx
  id: variable
  parameters:
    value: '[(complex(x)-0.5)*2 for x in list(access_code)]'
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,1)
  states: {}
- name: lowpassfiltertaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: fc
    gain: '1.0'
    samp_rate: samp_rate
    width: deviation*1.5
    win: window.WIN_HAMMING
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*deviation
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: audio_in
  id: parameter
  parameters:
    label: Audio Input
    type: str
    value: plughw:0,0,0
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[0,]'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: BFSK Deviation
    type: eng_float
    value: '800'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '1'
    symbols: access_code_cplx
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"payload symbols"'
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: 12*8
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '""'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: format_used
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Center frequency
    type: eng_float
    value: '3000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc
    decim: '1'
    samp_rate: samp_rate
    taps: lowpassfiltertaps
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: udp_out_host
    header: '0'
    payloadsize: pkt_size
    port: udp_out_port
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: payload symbols
    type: byte
  states: {}
- name: pkt_size
  id: parameter
  parameters:
    label: Packet size
    type: intx
    value: '16'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx symbols"'
    size: 5*sps
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '1500'
  states: {}
- name: udp_out_host
  id: parameter
  parameters:
    label: UDP Output Host
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_out_port
  id: parameter
  parameters:
    label: UDP Output Port
    type: intx
    value: '47898'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: hdr_bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: payload_symbols
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: hdr_bits
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: payload_symbols
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_float_1, '0', digital_binary_slicer_fb_1, '0']
- [blocks_complex_to_float_1, '1', blocks_null_sink_1, '0']
- [blocks_float_to_complex_0, '0', digital_corr_est_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_1, '0']
- [blocks_vector_source_x_1, '0', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_protocol_parser_b_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_binary_slicer_fb_2, '0', virtual_sink_5, '0']
- [digital_corr_est_cc_0, '0', digital_header_payload_demux_0, '0']
- [digital_crc32_bb_1, '0', network_udp_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_3, '0']
- [digital_protocol_parser_b_0, info, blocks_message_debug_0, print]
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_1, print]
- [virtual_source_1, '0', blocks_complex_to_float_0, '0']
- [virtual_source_3, '0', blocks_complex_to_float_1, '0']
- [virtual_source_4, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
