options:
  parameters:
    generate_options: qt_gui
    id: bfsk_receive
    output_language: python
    title: BFSK Receive
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: constellation_bpsk
  id: variable_constellation
  parameters:
    npwr: '0'
    precision: '8'
    type: bpsk
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: variable
  parameters:
    value: packet_size*num_pream_packets
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: passband_fc+deviation
    interp: '1'
    low_cutoff_freq: passband_fc-deviation
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav_in
    repeat: 'True'
  states: {}
- name: custom_bfsk_demod_0
  id: custom_bfsk_demod
  parameters:
    deviation: deviation
    fc: passband_fc
    sps: sps
  states: {}
- name: custom_packet_parser_0
  id: custom_packet_parser
  parameters:
    samp_rate: '48000'
  states: {}
- name: custom_remove_preamble_0
  id: custom_remove_preamble
  parameters:
    num_pream_packets: num_pream_packets
  states: {}
- name: dest_host
  id: parameter
  parameters:
    label: Destination Host
    type: str
    value: 127.0.0.1
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    type: str
    value: '42028'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Deviation bandwidth for 2-FSK modulation
    type: eng_float
    value: '600'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: dest_host
    mode: '1'
    port: int(dest_port)
    type: byte
  states: {}
- name: num_pream_packets
  id: parameter
  parameters:
    label: Number of preamble garbage packets
    type: intx
    value: '2'
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet Size
    type: intx
    value: '4'
  states: {}
- name: passband_fc
  id: parameter
  parameters:
    label: Passband Center Frequency
    type: eng_float
    value: '2800'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampe Rate
    type: eng_float
    value: '48000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '5400'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}
- name: wav_in
  id: parameter
  parameters:
    label: Waveform file input
    type: str
    value: record.wav
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_source
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zmq_source
  id: parameter
  parameters:
    label: ZMQ Source
    type: str
    value: tcp://10.0.4.105:14748
  states: {}

connections:
- [band_pass_filter_0, '0', custom_bfsk_demod_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [custom_bfsk_demod_0, '0', virtual_sink_0_0, '0']
- [custom_packet_parser_0, '0', custom_remove_preamble_0, '0']
- [custom_packet_parser_0, header_data, blocks_message_debug_1_0, print]
- [custom_remove_preamble_0, out, blocks_message_debug_1, print]
- [custom_remove_preamble_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [virtual_source_0, '0', custom_packet_parser_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
