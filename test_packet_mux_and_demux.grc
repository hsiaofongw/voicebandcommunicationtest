options:
  parameters:
    generate_options: qt_gui
    id: test_packet_mux_and_demux
    output_language: python
    title: Test packet mux and demux
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: constellationobj
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: format_default
  id: variable
  parameters:
    value: digital.header_format_default(access_code,0)
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: variable
  parameters:
    value: packet_size*num_pream_packets
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constellationobj
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps+1
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: passband_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: passband_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    log_level: debug
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*txgain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Realize the control of the on/off of the random signal
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Here is the control signal  to control the on/off of the random signal
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_2
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,)
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: wav_out
    format: FORMAT_WAV
    samp_rate: int(samp_rate)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noisevoltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: dest_host
  id: parameter
  parameters:
    label: Destination Host
    type: str
    value: 127.0.0.1
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    type: str
    value: '42028'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellationobj
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellationobj
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"frame_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_2
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_3
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '96'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"frame_len"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '""'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: filtersize
    init_phase: '0'
    loop_bw: 2*3.14/100
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: variable_rrc_filter_taps_0
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: format_used
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_1
  id: digital_protocol_formatter_bb
  parameters:
    format: format_default
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: format_used
  states: {}
- name: filtersize
  id: parameter
  parameters:
    label: Polyphase Clock Sync Filter size
    type: intx
    value: '84'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: Input filename
    type: str
    value: in.bin
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: passband_fc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: passband_fc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: dest_host
    mode: '1'
    port: int(dest_port)
    type: byte
  states: {}
- name: noisevoltage
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0.1'
  states: {}
- name: num_pream_packets
  id: parameter
  parameters:
    label: Number of preamble garbage packets
    type: intx
    value: '10'
  states: {}
- name: out
  id: parameter
  parameters:
    label: Output filename
    type: str
    value: out.bin
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet Size
    type: intx
    value: '16'
  states: {}
- name: passband_fc
  id: parameter
  parameters:
    label: Passband Center Frequency
    type: eng_float
    value: '1800'
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("select")
    v: pmt.PMT_T
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.dict_add(x, pmt.string_to_symbol("frame_len"), pmt.from_long(8*pmt.to_long(pmt.dict_ref(x,pmt.string_to_symbol("payload symbols"),pmt.from_long(0)))))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.cons(pmt.to_pmt({ ''select'': True }) if pmt.to_long(pmt.dict_ref(pmt.car(x), pmt.string_to_symbol("counter"), pmt.from_long(0))) >= num_pream_packets else pmt.to_pmt({ ''select'': False }), pmt.cdr(x))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"Rx symbols"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx signal"'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampe Rate
    type: eng_float
    value: '48000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '72'
  states: {}
- name: txgain
  id: parameter
  parameters:
    label: Tx Gain
    type: eng_float
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: payload_bytestream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: first_round_decapsulate_bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: second_round_decapsulate_bytes
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: basebandsignal
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: payload_bytestream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bytes_tx
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: basebandsignal
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: first_round_decapsulate_bits
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: second_round_decapsulate_bytes
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_0_0_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0_0_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_1, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_throttle2_1, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_1_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_2, '0', digital_crc32_bb_2, '0']
- [blocks_repack_bits_bb_3, '0', virtual_sink_2, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_3, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_1, '0', virtual_sink_4, '0']
- [blocks_tagged_stream_mux_0, '0', digital_crc32_bb_1, '0']
- [blocks_tagged_stream_mux_2, '0', blocks_tag_gate_0, '0']
- [blocks_throttle2_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_float_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_1, '0', blocks_tagged_stream_mux_2, '1']
- [digital_crc32_bb_1, '0', digital_protocol_formatter_bb_1, '0']
- [digital_crc32_bb_2, '0', blocks_repack_bits_bb_3, '0']
- [digital_crc32_bb_3, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_3, '0', digital_protocol_formatter_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_1, '0', blocks_tagged_stream_mux_2, '0']
- [digital_protocol_parser_b_0, info, pdu_pdu_lambda_0, pdu]
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [pdu_pdu_filter_0, pdus, blocks_message_debug_1, print]
- [pdu_pdu_filter_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_lambda_0, pdu, digital_header_payload_demux_0, header_data]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_filter_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, pdu_pdu_lambda_1, pdu]
- [virtual_source_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [virtual_source_1_0, '0', blocks_multiply_xx_0_1, '1']
- [virtual_source_1_0_0, '0', blocks_tag_gate_1, '0']
- [virtual_source_2, '0', digital_constellation_modulator_0, '0']
- [virtual_source_3, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_4, '0', digital_header_payload_demux_0, '0']
- [virtual_source_5, '0', pdu_tagged_stream_to_pdu_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
