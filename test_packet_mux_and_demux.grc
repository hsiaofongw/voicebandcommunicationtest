options:
  parameters:
    generate_options: no_gui
    id: test_packet_mux_and_demux
    output_language: python
    title: Test packet mux and demux
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: format_default
  id: variable
  parameters:
    value: digital.header_format_default(access_code,0)
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: variable
  parameters:
    value: packet_size*10
  states: {}
- name: num_pream_packets
  id: variable
  parameters:
    value: int(garbage_preamble_length_n_bytes/packet_size)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: out
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    log_level: debug
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Realize the control of the on/off of the random signal
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Here is the control signal  to control the on/off of the random signal
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_2
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: read_throttle
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,)
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"frame_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_2
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_3
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '96'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"frame_len"'
    output_symbols: 'False'
    samp_rate: read_throttle
    special_tags: ()
    timing_tag_key: '""'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: format_used
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_1
  id: digital_protocol_formatter_bb
  parameters:
    format: format_default
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: format_used
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: Input filename
    type: str
    value: in.bin
  states: {}
- name: out
  id: parameter
  parameters:
    label: Output filename
    type: str
    value: out.bin
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet Size
    type: intx
    value: '64'
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("select")
    v: pmt.PMT_T
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.dict_add(x, pmt.string_to_symbol("frame_len"), pmt.from_long(8*pmt.to_long(pmt.dict_ref(x,pmt.string_to_symbol("payload symbols"),pmt.from_long(0)))))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.cons(pmt.to_pmt({ ''select'': True }) if pmt.to_long(pmt.dict_ref(pmt.car(x), pmt.string_to_symbol("counter"), pmt.from_long(0))) >= num_pream_packets else pmt.to_pmt({ ''select'': False }), pmt.cdr(x))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: frame_len
    type: byte
  states: {}
- name: read_throttle
  id: parameter
  parameters:
    label: Read throttle (bytes per second)
    type: intx
    value: '1024'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: payload_bytestream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: payload_bytestream
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_tag_gate_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_2, '0', digital_crc32_bb_2, '0']
- [blocks_repack_bits_bb_3, '0', digital_header_payload_demux_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_3, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_crc32_bb_1, '0']
- [blocks_tagged_stream_mux_2, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_mux_2, '0', blocks_repack_bits_bb_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_crc32_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_1, '0', blocks_tagged_stream_mux_2, '1']
- [digital_crc32_bb_1, '0', digital_protocol_formatter_bb_1, '0']
- [digital_crc32_bb_2, '0', blocks_repack_bits_bb_3, '0']
- [digital_crc32_bb_3, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_3, '0', digital_protocol_formatter_bb_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_1, '0', blocks_tagged_stream_mux_2, '0']
- [digital_protocol_parser_b_0, info, pdu_pdu_lambda_0, pdu]
- [pdu_pdu_filter_0, pdus, blocks_message_debug_1, print]
- [pdu_pdu_filter_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_lambda_0, pdu, digital_header_payload_demux_0, header_data]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_filter_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, pdu_pdu_lambda_1, pdu]
- [virtual_source_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_1, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
