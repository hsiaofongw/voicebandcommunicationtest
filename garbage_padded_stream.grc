options:
  parameters:
    generate_options: hb
    id: garbage_padded_stream
    output_language: python
    title: Garbage padded stream
  states: {}

blocks:
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: garbage_preamble_length_n_bytes
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Realize the control of the on/off of the random signal
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Here is the control signal  to control the on/off of the random signal
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: parameter
  parameters:
    label: 'Garbage preamble length '
    value: '32'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_float_to_char_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
