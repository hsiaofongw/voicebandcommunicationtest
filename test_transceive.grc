options:
  parameters:
    generate_options: qt_gui
    id: test_transceive
    output_language: python
    title: Test transceiving
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: adaptive_algorithm_bpsk
  id: variable_adaptive_algorithm
  parameters:
    cons: constellation_bpsk
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: adaptive_algorithm_qpsk
  id: variable_adaptive_algorithm
  parameters:
    cons: constellation_qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {state: disabled}
- name: constellation_bpsk
  id: variable_constellation
  parameters:
    npwr: '0'
    precision: '8'
    type: bpsk
  states: {}
- name: constellation_qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {state: disabled}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: variable
  parameters:
    value: packet_size*num_pream_packets
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps+1
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: wav_out
    format: FORMAT_WAV
    samp_rate: int(samp_rate)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noisevoltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: custom_iq_complex_to_passband_real_0
  id: custom_iq_complex_to_passband_real
  parameters:
    passband_fc: passband_fc
    samp_rate: samp_rate
    txgain: txgain
  states: {}
- name: custom_packet_formatter_0
  id: custom_packet_formatter
  parameters:
    access_code: access_code
    packet_size: packet_size
  states: {}
- name: custom_packet_parser_0
  id: custom_packet_parser
  parameters:
    samp_rate: '48000'
  states: {}
- name: custom_passband_real_to_iq_complex_0
  id: custom_passband_real_to_iq_complex
  parameters:
    passband_fc: passband_fc
    samp_rate: samp_rate
  states: {}
- name: custom_remove_preamble_0
  id: custom_remove_preamble
  parameters:
    num_pream_packets: num_pream_packets
  states: {}
- name: custom_stream_prepend_0
  id: custom_stream_prepend
  parameters:
    garbage_preamble_length_n_bytes: garbage_preamble_length_n_bytes
  states: {}
- name: dest_host
  id: parameter
  parameters:
    label: Destination Host
    type: str
    value: 127.0.0.1
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    type: str
    value: '42028'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation_bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14/100
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.14/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adaptive_algorithm_bpsk
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: filtersize
    init_phase: '0'
    loop_bw: 2*3.14/100
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: variable_rrc_filter_taps_0
    type: ccf
  states: {}
- name: filtersize
  id: parameter
  parameters:
    label: Polyphase Clock Sync Filter size
    type: intx
    value: '84'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: Input filename
    type: str
    value: in.bin
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: dest_host
    mode: '1'
    port: int(dest_port)
    type: byte
  states: {}
- name: noisevoltage
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0.1'
  states: {}
- name: num_pream_packets
  id: parameter
  parameters:
    label: Number of preamble garbage packets
    type: intx
    value: '20'
  states: {}
- name: out
  id: parameter
  parameters:
    label: Output filename
    type: str
    value: out.bin
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet Size
    type: intx
    value: '16'
  states: {}
- name: passband_fc
  id: parameter
  parameters:
    label: Passband Center Frequency
    type: eng_float
    value: '3600'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"Rx symbols"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx signal"'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampe Rate
    type: eng_float
    value: '48000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '72'
  states: {}
- name: txgain
  id: parameter
  parameters:
    label: Tx Gain
    type: eng_float
    value: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: basebandsignal
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bytes_tx
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: basebandsignal
  states: {}
- name: wav_out
  id: parameter
  parameters:
    label: Waveform output
    type: str
    value: out.wav
  states: {}

connections:
- [analog_random_source_x_0, '0', custom_stream_prepend_0, '1']
- [blocks_file_source_0, '0', custom_stream_prepend_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_1, '0', virtual_sink_4, '0']
- [blocks_throttle2_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle2_1, '0', virtual_sink_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [custom_iq_complex_to_passband_real_0, '0', blocks_throttle2_1, '0']
- [custom_packet_formatter_0, '0', blocks_tag_gate_0, '0']
- [custom_packet_parser_0, '0', custom_remove_preamble_0, '0']
- [custom_packet_parser_0, header_data, blocks_message_debug_1_0, print]
- [custom_passband_real_to_iq_complex_0, '0', channels_channel_model_0, '0']
- [custom_remove_preamble_0, out, blocks_message_debug_1, print]
- [custom_remove_preamble_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [custom_stream_prepend_0, '0', custom_packet_formatter_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', custom_iq_complex_to_passband_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', virtual_sink_3_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', virtual_sink_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [virtual_source_0, '0', custom_packet_parser_0, '0']
- [virtual_source_1_0, '0', custom_passband_real_to_iq_complex_0, '0']
- [virtual_source_1_0_0, '0', blocks_tag_gate_1, '0']
- [virtual_source_2, '0', digital_constellation_modulator_0, '0']
- [virtual_source_3, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
