options:
  parameters:
    generate_options: hb
    id: custom_bfsk_mod
    output_language: python
    title: Custom BFSK Mod
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*deviation
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: fc/(sensitivity/(2*math.pi))
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: sensitivity
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Deviation
    type: eng_float
    value: '400'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Center Frequency
    type: eng_float
    value: '2400'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '1500'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_vco_f_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
