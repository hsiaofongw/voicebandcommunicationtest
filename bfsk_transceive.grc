options:
  parameters:
    generate_options: qt_gui
    id: bfsk_transceive
    output_language: python
    title: BFSK tranceving
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: constellation_bpsk
  id: variable_constellation
  parameters:
    npwr: '0'
    precision: '8'
    type: bpsk
  states: {}
- name: format_used
  id: variable
  parameters:
    value: digital.header_format_counter(access_code,0,8)
  states: {}
- name: garbage_preamble_length_n_bytes
  id: variable
  parameters:
    value: packet_size*num_pream_packets
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: passband_fc+deviation
    interp: '1'
    low_cutoff_freq: passband_fc-deviation
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: wav_out
    format: FORMAT_WAV
    samp_rate: int(samp_rate)
  states: {}
- name: custom_bfsk_demod_0
  id: custom_bfsk_demod
  parameters:
    deviation: deviation
    fc: passband_fc
    sps: sps
  states: {}
- name: custom_bfsk_mod_0
  id: custom_bfsk_mod
  parameters:
    deviation: deviation
    fc: passband_fc
    sps: sps
  states: {}
- name: custom_packet_formatter_0
  id: custom_packet_formatter
  parameters:
    access_code: access_code
    packet_size: packet_size
  states: {}
- name: custom_packet_parser_0
  id: custom_packet_parser
  parameters:
    samp_rate: '48000'
  states: {}
- name: custom_remove_preamble_0
  id: custom_remove_preamble
  parameters:
    num_pream_packets: num_pream_packets
  states: {}
- name: custom_stream_prepend_0
  id: custom_stream_prepend
  parameters:
    garbage_preamble_length_n_bytes: garbage_preamble_length_n_bytes
  states: {}
- name: dest_host
  id: parameter
  parameters:
    label: Destination Host
    type: str
    value: 127.0.0.1
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    type: str
    value: '42028'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Deviation bandwidth for 2-FSK modulation
    type: eng_float
    value: '600'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: passband_fc+deviation
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: Input filename
    type: str
    value: in.bin
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: dest_host
    mode: '1'
    port: int(dest_port)
    type: byte
  states: {}
- name: num_pream_packets
  id: parameter
  parameters:
    label: Number of preamble garbage packets
    type: intx
    value: '2'
  states: {}
- name: packet_size
  id: parameter
  parameters:
    label: Packet Size
    type: intx
    value: '4'
  states: {}
- name: passband_fc
  id: parameter
  parameters:
    label: Passband Center Frequency
    type: eng_float
    value: '2800'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampe Rate
    type: eng_float
    value: '48000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '5400'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: txsignal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bytes_tx
  states: {}
- name: wav_out
  id: parameter
  parameters:
    label: Waveform output
    type: str
    value: out.wav
  states: {}

connections:
- [analog_random_source_x_0, '0', custom_stream_prepend_0, '1']
- [band_pass_filter_0, '0', custom_bfsk_demod_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0, '0', custom_stream_prepend_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_1, '0', virtual_sink_4, '0']
- [blocks_throttle2_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle2_1, '0', virtual_sink_1_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', custom_bfsk_mod_0, '0']
- [custom_bfsk_demod_0, '0', virtual_sink_0_0, '0']
- [custom_bfsk_mod_0, '0', filter_fft_low_pass_filter_0, '0']
- [custom_packet_formatter_0, '0', blocks_tag_gate_0, '0']
- [custom_packet_parser_0, '0', custom_remove_preamble_0, '0']
- [custom_packet_parser_0, header_data, blocks_message_debug_1_0, print]
- [custom_remove_preamble_0, out, blocks_message_debug_1, print]
- [custom_remove_preamble_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [custom_stream_prepend_0, '0', custom_packet_formatter_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_throttle2_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [virtual_source_0, '0', custom_packet_parser_0, '0']
- [virtual_source_1_0, '0', band_pass_filter_0, '0']
- [virtual_source_1_0_0, '0', blocks_tag_gate_1, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
