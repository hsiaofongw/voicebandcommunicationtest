options:
  parameters:
    generate_options: qt_gui
    id: qpskreceiver
    output_language: python
    title: QPSK Receiver
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: format_obj
  id: variable
  parameters:
    value: digital.header_format_default(access_code, 0)
  states: {}
- name: passband_fc
  id: variable
  parameters:
    value: '1700'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps+1
    ntaps: sps*4
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: passband_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: dest_host
  id: parameter
  parameters:
    label: Destination Host
    type: str
    value: 127.0.0.1
  states: {}
- name: dest_port
  id: parameter
  parameters:
    label: Destination Port
    type: str
    value: '42028'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: filtersize
    init_phase: '0'
    loop_bw: 2*3.14/100
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: variable_rrc_filter_taps_0
    type: ccf
  states: {}
- name: filtersize
  id: parameter
  parameters:
    label: Polyphase Clock Sync Filter size
    type: intx
    value: '8'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: passband_fc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: passband_fc
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: dest_host
    mode: '1'
    port: int(dest_port)
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '150'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: float
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '64'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: basebandsignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rxbits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rxsignal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: basebandsignal
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmqsource
    timeout: '100'
    type: float
  states: {}
- name: zmqsource
  id: parameter
  parameters:
    label: ZMQ Source address
    type: str
    value: tcp://127.0.0.1:13535
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_1, '0', blocks_char_to_float_0, '0']
- [digital_crc32_bb_1, '0', network_tcp_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [virtual_source_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_1, '1']
- [virtual_source_3, '0', digital_constellation_decoder_cb_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', virtual_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
